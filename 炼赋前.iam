# Autodesk Inventor assembly: 조립품
## iProperties
Created: 2014-10
Part Number: 조립품
Document SubType Name: Assembly
Designer: tw_037
Author: tw_037
